<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\uCOS-III-Ex1\uCOS-III-Ex1.ewp</path>
    </project>
    <batchBuild />
</workspace>
